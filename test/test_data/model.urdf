Commit message: Update transformations

File: test/test_data/model.urdf (robot description, URDF)
Before this commit: robot compi, 2 links, 1 joints
Links:
- removed link dynamixel/lower
- added link lower_dynamixel
Joints:
- joint offset: child dynamixel/lower -> lower_dynamixel
